Commit message: ATTEMPT3 or 4 obstacle

File: simple_driving/resources/simpleObstacle.urdf (robot description, URDF)
Before this commit: robot simpleobstacle, 1 links, 0 joints
Links:
- link base_link: mass 45 -> 0; geometry collision box size=1 1 1; visual box size=1 1 1
